## config/boards/shields/KillerBoard/Kconfig.defconfig
```kconfig
if SHIELD_KILLERBOARD

config ZMK_KEYBOARD_NAME
    default "KillerBoard"

endif
```
